!Agilent Technologies,E8363B,SG43030131,A.07.50.48
!Agilent E8363B: A.07.50.48
!Date: Wednesday, December 17, 2025 22:44:16
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 2 GHz to 18 GHz, reference 50 ohm
!   highest |S21| = -21.00 dB at 2.96 GHz (marker M1); lowest = -56.0 dB at 15.2 GHz (marker M2)
!   lowest |S11| = -37.4 dB at 11.44 GHz (marker M3), VSWR 1.03, Z = 49.3 - j1.14 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -50.1 to -14.8 dB; largest |S21 - S12| = 0.0002
!   S11 on the Smith chart (normalised r, x): 2 GHz: 0.76, +0.31; 5.12 GHz: 0.93, -0.05; 18 GHz: 1.16, -0.21
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 2 GHz  -13.3  -34.3  -34.3  -15.2
! 2.96 GHz  -17.7  -21.0  -21.0  -19.8
! 3.92 GHz  -22.7  -24.8  -24.8  -33.1
! 4.72 GHz  -28.2  -30.6  -30.5  -24.2
! 5.12 GHz  -27.1  -26.6  -26.6  -22.7
! 7.36 GHz  -22.1  -27.8  -27.8  -17.2
! 8.48 GHz  -23.8  -26.3  -26.3  -19.2
! 9.04 GHz  -24.7  -51.5  -51.4  -18.2
! 9.28 GHz  -20.8  -32.8  -32.8  -17.2
! 10 GHz  -18.5  -24.1  -24.1  -17.6
! 10.56 GHz  -22.3  -22.9  -22.9  -26.3
! 10.8 GHz  -23.4  -23.3  -23.3  -50.1
! 10.96 GHz  -24.2  -24.0  -24.0  -28.7
! 11.44 GHz  -37.4  -30.3  -30.3  -18.3
! 11.76 GHz  -21.3  -50.2  -50.2  -16.6
! 12.08 GHz  -17.1  -30.3  -30.3  -17.1
! 12.72 GHz  -20.0  -23.9  -23.9  -25.3
! 13.04 GHz  -22.8  -24.2  -24.2  -40.7
! 14.72 GHz  -13.6  -31.4  -31.4  -16.0
! 15.2 GHz  -14.8  -56.0  -56.0  -14.8
! 15.36 GHz  -15.9  -38.9  -38.9  -15.0
! 18 GHz  -18.3  -27.9  -27.9  -20.3
