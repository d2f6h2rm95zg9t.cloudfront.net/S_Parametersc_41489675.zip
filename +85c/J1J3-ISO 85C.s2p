!Agilent Technologies,E8363B,SG43030131,A.07.50.48
!Agilent E8363B: A.07.50.48
!Date: Wednesday, December 17, 2025 22:43:24
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 2 GHz to 18 GHz, reference 50 ohm
!   highest |S21| = -21.04 dB at 2 GHz (marker M1); lowest = -47.6 dB at 17.44 GHz (marker M2)
!   lowest |S11| = -39.5 dB at 14.08 GHz (marker M3), VSWR 1.02, Z = 49.8 - j1.05 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -50.4 to -14.8 dB; largest |S21 - S12| = 0.00015
!   S11 on the Smith chart (normalised r, x): 2 GHz: 0.76, +0.15; 6.64 GHz: 1.11, +0.14; 11.68 GHz: 0.96, -0.08; 18 GHz: 1.11, -0.40
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 2 GHz  -16.0  -21.0  -21.0  -15.2
! 3.92 GHz  -32.2  -33.2  -33.3  -33.2
! 4.72 GHz  -28.6  -41.6  -41.5  -24.3
! 6.24 GHz  -31.3  -42.8  -42.8  -26.3
! 6.64 GHz  -21.6  -40.5  -40.5  -23.4
! 7.36 GHz  -17.5  -36.1  -36.1  -17.2
! 10 GHz  -17.4  -27.0  -27.0  -17.6
! 10.56 GHz  -27.0  -32.3  -32.3  -26.2
! 10.8 GHz  -19.5  -36.0  -36.0  -50.4
! 10.88 GHz  -18.4  -37.4  -37.5  -34.4
! 11.04 GHz  -17.3  -40.3  -40.4  -25.5
! 11.68 GHz  -26.7  -41.0  -40.9  -16.8
! 12.24 GHz  -18.0  -35.0  -35.1  -18.0
! 12.72 GHz  -28.3  -33.4  -33.4  -25.2
! 13.04 GHz  -23.4  -34.0  -34.0  -40.6
! 13.6 GHz  -18.9  -32.6  -32.6  -24.1
! 14.08 GHz  -39.5  -28.9  -28.9  -20.0
! 14.48 GHz  -19.7  -27.8  -27.8  -17.3
! 15.36 GHz  -17.4  -30.1  -30.1  -15.0
! 16.72 GHz  -18.6  -28.2  -28.2  -24.2
! 17.44 GHz  -15.4  -47.6  -47.6  -22.9
! 18 GHz  -14.3  -30.4  -30.4  -20.2
