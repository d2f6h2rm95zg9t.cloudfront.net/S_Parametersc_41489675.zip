!Agilent Technologies,E8363B,SG43030131,A.07.50.48
!Agilent E8363B: A.07.50.48
!Date: Wednesday, December 17, 2025 22:45:48
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 2 GHz to 18 GHz, reference 50 ohm
!   highest |S21| = -23.50 dB at 7.84 GHz (marker M1); lowest = -48.8 dB at 8.96 GHz (marker M2)
!   lowest |S11| = -38.4 dB at 14.08 GHz (marker M3), VSWR 1.02, Z = 49.3 - j0.962 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -33.0 to -13.4 dB; largest |S21 - S12| = 0.00017
!   S11 on the Smith chart (normalised r, x): 2 GHz: 0.77, +0.15; 6.64 GHz: 1.10, +0.15; 11.68 GHz: 0.95, -0.07; 18 GHz: 1.12, -0.40
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 2 GHz  -16.1  -42.0  -42.0  -13.4
! 2.88 GHz  -16.6  -24.4  -24.4  -18.9
! 4.16 GHz  -35.3  -34.4  -34.4  -21.5
! 4.72 GHz  -28.3  -39.3  -39.3  -22.8
! 5.84 GHz  -25.7  -28.2  -28.2  -33.0
! 6.64 GHz  -21.3  -33.8  -33.8  -23.8
! 7.36 GHz  -17.7  -25.3  -25.3  -23.0
! 7.84 GHz  -18.4  -23.5  -23.5  -24.9
! 8.56 GHz  -15.9  -29.5  -29.5  -24.2
! 8.96 GHz  -18.3  -48.8  -48.7  -22.5
! 9.28 GHz  -18.0  -32.0  -32.0  -21.8
! 10 GHz  -17.6  -25.7  -25.7  -22.5
! 10.48 GHz  -33.1  -25.2  -25.2  -24.7
! 10.96 GHz  -17.9  -26.7  -26.7  -24.4
! 11.68 GHz  -26.7  -36.2  -36.2  -19.1
! 12.24 GHz  -17.5  -28.4  -28.4  -19.9
! 12.72 GHz  -27.0  -26.2  -26.2  -24.2
! 13.6 GHz  -18.8  -28.7  -28.7  -21.6
! 14.08 GHz  -38.4  -27.7  -27.7  -19.5
! 14.56 GHz  -18.5  -26.6  -26.6  -16.9
! 15.36 GHz  -17.5  -34.4  -34.4  -14.2
! 18 GHz  -14.2  -24.0  -24.0  -25.8
