!Agilent Technologies,E8363B,SG43030131,A.07.50.48
!Agilent E8363B: A.07.50.48
!Date: Wednesday, December 17, 2025 23:07:04
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 2 GHz to 18 GHz, reference 50 ohm
!   highest |S21| = -20.91 dB at 2 GHz (marker M1); lowest = -50.3 dB at 17.36 GHz (marker M2)
!   lowest |S11| = -46.0 dB at 14.08 GHz (marker M3), VSWR 1.01, Z = 49.7 + j0.431 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -43.7 to -15.1 dB; largest |S21 - S12| = 0.00022
!   S11 on the Smith chart (normalised r, x): 2 GHz: 0.76, +0.13; 6.8 GHz: 1.24, +0.01; 18 GHz: 1.04, -0.42
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 2 GHz  -16.2  -20.9  -20.9  -15.3
! 3.2 GHz  -19.5  -27.5  -27.5  -23.1
! 4 GHz  -37.8  -35.2  -35.2  -40.4
! 4.4 GHz  -45.7  -40.3  -40.2  -29.3
! 4.72 GHz  -31.9  -42.8  -42.9  -25.2
! 6.8 GHz  -19.2  -40.5  -40.5  -21.1
! 7.36 GHz  -17.4  -36.8  -36.8  -16.8
! 10 GHz  -17.7  -26.0  -25.9  -17.7
! 10.4 GHz  -30.6  -29.1  -29.1  -21.9
! 10.8 GHz  -18.3  -34.1  -34.1  -43.7
! 10.96 GHz  -17.1  -36.2  -36.2  -27.9
! 11.44 GHz  -23.5  -38.5  -38.5  -17.3
! 12.24 GHz  -16.4  -33.3  -33.3  -17.3
! 12.72 GHz  -27.4  -32.0  -32.0  -26.1
! 13.68 GHz  -19.8  -29.5  -29.5  -20.4
! 13.92 GHz  -26.9  -28.0  -28.0  -19.3
! 14.08 GHz  -46.0  -27.3  -27.3  -18.7
! 14.4 GHz  -20.0  -26.7  -26.7  -17.5
! 15.36 GHz  -17.3  -30.3  -30.3  -15.2
! 16.72 GHz  -18.2  -28.9  -28.9  -23.4
! 17.36 GHz  -14.8  -50.3  -50.3  -21.6
! 18 GHz  -14.0  -31.3  -31.3  -18.8
