!Agilent Technologies,E8363B,SG43030131,A.07.50.48
!Agilent E8363B: A.07.50.48
!Date: Wednesday, December 17, 2025 23:07:56
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 2 GHz to 18 GHz, reference 50 ohm
!   highest |S21| = -23.05 dB at 7.76 GHz (marker M1); lowest = -48.5 dB at 8.88 GHz (marker M2)
!   lowest |S11| = -48.1 dB at 14.08 GHz (marker M3), VSWR 1.01, Z = 49.8 + j0.356 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -39.2 to -13.9 dB; largest |S21 - S12| = 0.00015
!   S11 on the Smith chart (normalised r, x): 2 GHz: 0.76, +0.13; 6.8 GHz: 1.24, +0.01; 18 GHz: 1.03, -0.41
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 2 GHz  -16.2  -47.2  -47.2  -13.9
! 2.8 GHz  -16.8  -24.9  -24.9  -19.5
! 4.4 GHz  -45.5  -39.0  -39.0  -23.7
! 4.72 GHz  -32.0  -42.4  -42.4  -24.5
! 5.84 GHz  -24.2  -28.0  -28.0  -39.2
! 6.8 GHz  -19.3  -30.9  -30.9  -23.5
! 7.36 GHz  -17.4  -24.4  -24.4  -22.5
! 7.76 GHz  -17.4  -23.1  -23.0  -22.8
! 8.48 GHz  -15.1  -29.1  -29.1  -23.7
! 8.88 GHz  -18.7  -48.5  -48.5  -23.2
! 9.2 GHz  -18.7  -30.8  -30.8  -22.5
! 10 GHz  -17.6  -25.5  -25.5  -23.2
! 10.4 GHz  -30.1  -25.7  -25.7  -24.3
! 10.96 GHz  -17.0  -27.8  -27.8  -23.4
! 12.72 GHz  -27.4  -26.3  -26.3  -23.8
! 13.68 GHz  -19.8  -29.3  -29.3  -19.9
! 13.92 GHz  -26.9  -28.4  -28.4  -19.4
! 14.08 GHz  -48.1  -27.6  -27.6  -19.0
! 14.16 GHz  -31.1  -27.2  -27.2  -18.7
! 14.4 GHz  -20.0  -26.5  -26.5  -17.7
! 15.36 GHz  -17.2  -38.4  -38.4  -14.6
! 18 GHz  -14.0  -25.0  -25.0  -23.7
