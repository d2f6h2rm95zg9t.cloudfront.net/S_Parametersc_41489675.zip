!Agilent Technologies,E8363B,SG43030131,A.07.50.48
!Agilent E8363B: A.07.50.48
!Date: Wednesday, December 17, 2025 23:05:48
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 2 GHz to 18 GHz, reference 50 ohm
!   highest |S21| = -21.46 dB at 2.96 GHz (marker M1); lowest = -69.4 dB at 15.12 GHz (marker M2)
!   lowest |S11| = -44.1 dB at 11.28 GHz (marker M3), VSWR 1.01, Z = 50.6 - j0.0495 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -42.8 to -15.1 dB; largest |S21 - S12| = 0.00016
!   S11 on the Smith chart (normalised r, x): 2 GHz: 0.77, +0.29; 6.4 GHz: 1.04, +0.08; 9.36 GHz: 0.89, -0.17; 18 GHz: 1.12, -0.27
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 2 GHz  -13.6  -33.7  -33.7  -15.3
! 2.96 GHz  -18.5  -21.5  -21.5  -20.6
! 4 GHz  -25.1  -25.3  -25.3  -39.9
! 4.72 GHz  -31.2  -31.6  -31.6  -25.1
! 6.4 GHz  -27.2  -25.6  -25.6  -24.5
! 7.36 GHz  -21.9  -26.5  -26.5  -16.8
! 8.4 GHz  -22.6  -25.8  -25.8  -17.8
! 8.96 GHz  -25.7  -45.7  -45.7  -18.7
! 9.36 GHz  -19.5  -28.2  -28.2  -17.2
! 10 GHz  -18.9  -23.8  -23.8  -17.6
! 10.8 GHz  -24.0  -24.0  -23.9  -42.8
! 11.28 GHz  -44.1  -28.6  -28.6  -19.2
! 11.68 GHz  -20.3  -52.9  -53.0  -15.9
! 12 GHz  -16.1  -30.4  -30.4  -16.0
! 12.72 GHz  -19.3  -23.8  -23.8  -26.3
! 13.52 GHz  -27.2  -27.2  -27.1  -21.6
! 14.72 GHz  -13.4  -32.2  -32.2  -16.3
! 15.04 GHz  -14.1  -45.3  -45.3  -15.3
! 15.12 GHz  -14.6  -69.4  -70.1  -15.2
! 15.2 GHz  -15.2  -44.0  -44.1  -15.1
! 15.36 GHz  -16.7  -34.6  -34.6  -15.2
! 18 GHz  -17.1  -30.0  -30.0  -18.9
