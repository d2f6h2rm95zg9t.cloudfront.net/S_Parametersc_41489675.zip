!Agilent Technologies,E8363B,SG43030131,A.07.50.48
!Agilent E8363B: A.07.50.48
!Date: Wednesday, December 17, 2025 22:55:07
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 2 GHz to 18 GHz, reference 50 ohm
!   highest |S21| = -23.33 dB at 7.84 GHz (marker M1); lowest = -49.1 dB at 8.96 GHz (marker M2)
!   lowest |S11| = -41.1 dB at 14.08 GHz (marker M3), VSWR 1.02, Z = 49.2 - j0.243 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -34.2 to -13.5 dB; largest |S21 - S12| = 0.00021
!   S11 on the Smith chart (normalised r, x): 2 GHz: 0.76, +0.14; 6.72 GHz: 1.18, +0.11; 18 GHz: 1.11, -0.41
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 2 GHz  -16.1  -43.3  -43.2  -13.5
! 2.8 GHz  -16.5  -24.6  -24.6  -18.7
! 4.24 GHz  -38.1  -35.7  -35.7  -22.1
! 4.72 GHz  -29.1  -40.1  -40.1  -23.2
! 5.84 GHz  -25.4  -28.2  -28.2  -34.2
! 6.72 GHz  -20.3  -33.0  -33.0  -23.5
! 7.36 GHz  -17.6  -25.0  -25.0  -22.9
! 7.84 GHz  -18.0  -23.3  -23.3  -24.3
! 8.56 GHz  -15.7  -29.9  -29.9  -23.9
! 8.96 GHz  -18.3  -49.1  -49.1  -22.6
! 9.28 GHz  -18.1  -31.1  -31.1  -22.0
! 10 GHz  -17.8  -25.6  -25.6  -22.8
! 10.4 GHz  -32.1  -25.3  -25.3  -24.4
! 11.04 GHz  -17.4  -27.6  -27.6  -23.5
! 11.68 GHz  -27.0  -36.0  -36.0  -18.9
! 12.24 GHz  -17.1  -28.1  -28.1  -19.8
! 12.72 GHz  -26.9  -26.2  -26.2  -24.1
! 13.6 GHz  -19.0  -29.0  -29.0  -21.1
! 14.08 GHz  -41.1  -27.7  -27.7  -19.3
! 14.48 GHz  -19.4  -26.5  -26.5  -17.3
! 15.36 GHz  -17.6  -35.1  -35.1  -14.3
! 18 GHz  -14.1  -24.2  -24.3  -25.2
