!Agilent Technologies,E8363B,SG43030131,A.07.50.48
!Agilent E8363B: A.07.50.48
!Date: Wednesday, December 17, 2025 22:57:21
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 2 GHz to 18 GHz, reference 50 ohm
!   highest |S21| = -21.17 dB at 2.96 GHz (marker M1); lowest = -54.7 dB at 15.2 GHz (marker M2)
!   lowest |S11| = -43.3 dB at 11.36 GHz (marker M3), VSWR 1.01, Z = 50.1 - j0.67 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -47.9 to -14.9 dB; largest |S21 - S12| = 0.00017
!   S11 on the Smith chart (normalised r, x): 2 GHz: 0.76, +0.30; 5.44 GHz: 0.93, +0.04; 18 GHz: 1.16, -0.23
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 2 GHz  -13.4  -34.1  -34.1  -15.3
! 2.96 GHz  -18.0  -21.2  -21.2  -20.1
! 3.92 GHz  -23.2  -24.8  -24.8  -34.4
! 4.72 GHz  -29.2  -30.9  -30.9  -24.4
! 5.44 GHz  -27.7  -24.3  -24.3  -22.7
! 7.36 GHz  -22.0  -27.4  -27.4  -17.2
! 8.48 GHz  -23.3  -26.4  -26.4  -18.6
! 8.96 GHz  -25.6  -50.7  -50.7  -18.6
! 9.28 GHz  -20.9  -31.5  -31.5  -17.4
! 10 GHz  -19.0  -23.9  -23.9  -17.6
! 10.56 GHz  -22.8  -23.0  -23.0  -25.8
! 10.8 GHz  -23.9  -23.5  -23.5  -47.9
! 10.96 GHz  -24.9  -24.3  -24.3  -28.9
! 11.36 GHz  -43.3  -29.2  -29.2  -18.8
! 11.76 GHz  -20.0  -47.1  -47.1  -16.2
! 12.72 GHz  -19.4  -23.9  -23.9  -25.5
! 13.04 GHz  -21.7  -24.3  -24.3  -35.1
! 14.64 GHz  -13.7  -30.5  -30.5  -16.6
! 15.2 GHz  -15.0  -54.7  -54.7  -15.0
! 15.36 GHz  -16.2  -37.4  -37.5  -15.0
! 16.08 GHz  -20.5  -25.1  -25.1  -19.3
! 18 GHz  -17.8  -28.6  -28.6  -19.9
