!Agilent Technologies,E8363B,SG43030131,A.07.50.48
!Agilent E8363B: A.07.50.48
!Date: Wednesday, December 17, 2025 22:56:09
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 2 GHz to 18 GHz, reference 50 ohm
!   highest |S21| = -20.99 dB at 2 GHz (marker M1); lowest = -46.8 dB at 17.44 GHz (marker M2)
!   lowest |S11| = -41.7 dB at 14.08 GHz (marker M3), VSWR 1.02, Z = 49.2 - j0.18 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -47.8 to -14.9 dB; largest |S21 - S12| = 0.00011
!   S11 on the Smith chart (normalised r, x): 2 GHz: 0.76, +0.14; 6.72 GHz: 1.18, +0.11; 18 GHz: 1.10, -0.41
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 2 GHz  -16.1  -21.0  -21.0  -15.3
! 3.92 GHz  -32.9  -33.5  -33.5  -34.3
! 4.72 GHz  -29.2  -42.0  -42.0  -24.4
! 6.72 GHz  -20.3  -40.2  -40.1  -22.2
! 7.36 GHz  -17.6  -36.5  -36.5  -17.2
! 10 GHz  -17.8  -26.5  -26.6  -17.6
! 10.4 GHz  -32.1  -29.8  -29.8  -21.8
! 10.64 GHz  -23.3  -32.8  -32.8  -29.1
! 10.8 GHz  -19.3  -35.2  -35.2  -47.8
! 10.96 GHz  -17.6  -37.8  -37.8  -29.0
! 11.36 GHz  -20.2  -41.5  -41.5  -18.8
! 12.32 GHz  -17.4  -33.8  -33.8  -18.3
! 12.72 GHz  -26.9  -32.8  -32.8  -25.4
! 13.04 GHz  -23.2  -33.2  -33.2  -35.4
! 13.6 GHz  -19.0  -31.6  -31.6  -22.7
! 13.92 GHz  -26.2  -29.2  -29.2  -20.5
! 14.08 GHz  -41.7  -28.2  -28.3  -19.6
! 14.48 GHz  -19.3  -27.3  -27.4  -17.5
! 15.36 GHz  -17.6  -30.1  -30.1  -15.0
! 16.72 GHz  -18.3  -28.4  -28.4  -23.5
! 17.44 GHz  -15.0  -46.8  -46.7  -22.4
! 18 GHz  -14.1  -30.8  -30.8  -20.0
